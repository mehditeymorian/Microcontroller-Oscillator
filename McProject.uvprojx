# Keil uVision project McProject.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: McProject +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Main.h Display.c Display.h Wave.c Wave.h Input.c Input.h Main.c UsartUnit.c UsartUnit.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
